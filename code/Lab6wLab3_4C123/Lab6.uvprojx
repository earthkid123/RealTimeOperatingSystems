# Keil uVision project Lab6.uvprojx, settings and files
target Lab6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source code
    ../inc/: BSP.c Profile.c AP.c CortexM.c GPIO.c UART0.c UART1.c
    ./: osasm.s os.c AP_Lab6.c Lab6.c AES128.h AES128.c
  group Object code
    ./: texas.o
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
